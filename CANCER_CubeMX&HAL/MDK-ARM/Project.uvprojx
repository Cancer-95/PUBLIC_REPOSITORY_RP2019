# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;                 ../Drivers/STM32F4xx_HAL_Driver/Inc;                 ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                 ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                 ../Drivers/CMSIS/Include;                 .\app;                 .\bsp;                 .\lib;                 .\imu;                 .\imu\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: gpio.c stm32f4xx_it.c main.c stm32f4xx_hal_msp.c can.c usart.c dma.c tim.c
  group Application/UserBsp
    ./bsp/: bsp_sys.c bsp_can.c bsp_uart.c
  group Application/AppCtrl
    ./app/: led_ctrl.c omron_ctrl.c remote_ctrl.c keyboard_ctrl.c info_interactive.c
  group Application/AppTask
    ./app/: servo_task.c chassis_task.c
    ./imu/: imu_task.c
  group Application/CancerLib
    ./lib/: my_math.c my_pid.c my_ramp.c
  group Application/mpu6050
    ./imu/: mpu6050_iic.c mpu6050_driver.c
    ./imu/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 4.1.0
