# Keil uVision project project.uvprojx, settings and files
target Cancer_Engineer (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\APP;..\BSP;..\Libraries\inc;..\Libraries\src;..\Libraries\cmsis\Include;..\Libraries\cmsis;..\RM_lib;..\IMU\eMPL;..\IMU
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32_StdPeriph
    ../Libraries/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_syscfg.c stm32f4xx_dbgmcu.c
    ../Libraries/startup/: startup_stm32f40xx.s
    ../Libraries/cmsis/: system_stm32f4xx.c
  group Application/User
    ../APP/: stm32f4xx_it.c main.c system.c
    ../BSP/: nvic.c gpio.c can.c uart.c dma.c tim.c
  group Application/Peripherals
    ../BSP/: lifter.c assist_wheel.c bomb_claw.c trailer.c dutched.c servo.c omron.c relay.c led.c
  group Application/AppCtrl
    ../BSP/: chassis.c climb_tube.c get_bomb.c feed_bomb.c rescue.c sys_check.c
  group Application/ModeSw
    ../BSP/: modeswitch.c
  group Application/IMU
    ../IMU/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
    ../IMU/: mpu6050_iic.c mpu6050_driver.c
    ../BSP/: mpu6050_temp.c
  group Application/Wireless
    ../BSP/: keyboard.c remote_ctrl.c roboremo.c ano_tc.c
  group Application/Protocol&Comm
    ../BSP/: vision.c judgement.c
  group Application/Cancer_Lib
    ../BSP/: my_math.c pidckz.c ramp.c
  group Doc
    ../DOC/: read_me.txt
